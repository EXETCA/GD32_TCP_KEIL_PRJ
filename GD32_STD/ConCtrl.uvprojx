# Keil uVision project ConCtrl.uvprojx, settings and files
target ConCtrl (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F407ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ConCtrl +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Driver\CMSIS\GD\GD32F4xx\Include;.\Lib\GD32F4xx_standard_peripheral\Include;.\Lib\FreeRTOS\Source\include;.\Lib\LWIP\src\include;.\Lib\LWIP\src\include\netif;.\Lib\FreeRTOS\Source\portable\RVDS\ARM_CM4_MPU;.\Driver\CMSIS;.\Driver\CMSIS\GD\GD32F4xx\Include;.\Core\inc;.\Core\inc\lwip;.\Driver\CMSIS\_ARMCM4_FP;.\Lib\LWIP\src;.\Lib\LWIP\src\netif\ppp;.\Lib\LWIP\src\include\compat;.\Lib\LWIP\src\include\compat\stdc;.\Lib\LWIP\src\include\compat\posix;.\Lib\LWIP\src\include\netif\ppp;.\Lib\LWIP\src\include\netif\ppp\polarssl;.\Lib\LWIP\src\include\lwip;.\Lib\LWIP\src\include\lwip\apps;.\Lib\LWIP\src\include\lwip\priv;.\Lib\LWIP\src\include\lwip\prot;.\Lib\LWIP\src\arch;.\Driver\BSP;.\Lib\SEGGER\Config;.\Lib\SEGGER\RTT\Config;.\Lib\SEGGER\RTT;.\Lib\SEGGER\SystemView;.\Lib\SEGGER\SystemView\COMM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./Driver/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Driver/CMSIS
    ./Driver/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Lib/Std_lib
    ./Lib/GD32F4xx_standard_peripheral/Source/: gd32f4xx_fmc.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_timer.c gd32f4xx_exmc.c gd32f4xx_syscfg.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_spi.c
  group User
    ./Core/src/: main.c systick.c gd32f4xx_it.c netconf.c Cpld_Ctrl.c Tcp_Server.c
    ./Lib/LWIP/src/arch/: ethernetif.c sys_arch.c
    ./Driver/BSP/: eth_bsp_config.c
    ./Core/inc/: lwipopts.h FreeRTOSConfig.h
  group User/peripheral
    ./Core/Peripheral/: RTC.c RTC.h
  group Lib/FreeRTOS
    ./Lib/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Lib/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./Lib/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib/Lwip
    ./Lib/LWIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./Lib/LWIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c ip4.c igmp.c ip4_addr.c ip4_frag.c
    ./Lib/LWIP/src/netif/: ethernet.c
  group Lib/Lwip\aip
    ./Lib/LWIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c tcpip.c sockets.c
  group SEGGER
    ./Lib/SEGGER/SystemView/: SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW.c
    ./Lib/SEGGER/SystemView/Config/Cortex-M/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ./Lib/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
